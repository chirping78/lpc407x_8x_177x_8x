# Keil uVision project Emac_uIP.uvproj, settings and files
target FLASH_M3 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Emac_uIP +hex
  c flags: Optim=1 wLevel=2
  c include: ..\apps\webserver;..\lpc_port;..\uip;..\apps;..\common;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Core Files
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
  group Driver Files
    ../../../../Drivers/source/: debug_frmwrk.c lpc_uart.c lpc_clkpwr.c lpc_emac.c lpc_pinsel.c lpc_gpio.c
    ../../../../BoardSupport/: phylan.c
  group Readme
    ../: abstract.txt
  group port
    ../lpc_port/: clock-arch.c emac.c Emac_uIP.c
  group Common
    ../common/: Serial.c
  group uIP
    ../uip/: uip_arp.c psock.c timer.c uip.c
  group Webserver
    ../apps/webserver/: httpd-cgi.c httpd-fs.c http-strings.c httpd.c
target FLASH_M4 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Emac_uIP +hex
  c flags: Optim=1 wLevel=2
  c define: CORE_M4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
